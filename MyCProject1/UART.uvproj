# Keil uVision project UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: ExeHEX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App;.\App\Swc;.\Config;.\Device;.\Bsw\Common;.\Bsw\Service\EcuM;.\Bsw\Service\Det;.\Bsw\Service\Rte;.\Bsw\Service\SchM;.\Bsw\Service\Timer2;.\Bsw\Mcal\Uart;.\Bsw\Mcal\Delay;.\Bsw\Mcal\Dio;.\Bsw\Mcal\Adc;.\Bsw\Mcal\Iap;.\Bsw\Mcal\Iic;.\Bsw\Mcal\IrSensor;.\Bsw\EcuAb\Serial;.\Bsw\EcuAb\IoHwAb;.\Bsw\EcuAb\Display;.\Bsw\EcuAb\Lcd1602;.\Bsw\EcuAb\At24c02;.\Bsw\EcuAb\Led8
  asm include: as above
  group App
    ./App/: main.c App.c
    ./App/Swc/: Swc_AdcSampler.c Swc_Command.c Swc_Storage.c Swc_IrHandler.c Swc_LcdPresenter.c Swc_SerialTx.c
  group Bsw_Service
    ./Bsw/Service/EcuM/: EcuM.c
    ./Bsw/Service/Det/: Det.c
    ./Bsw/Service/Rte/: Rte.c
    ./Bsw/Service/SchM/: SchM.c
    ./Bsw/Service/Timer2/: Timer2.c
  group Bsw_Mcal
    ./Bsw/Mcal/Startup/: STARTUP.A51
    ./Bsw/Mcal/Delay/: Delay.c
    ./Bsw/Mcal/Dio/: Dio.c
    ./Bsw/Mcal/Uart/: Uart.c
    ./Bsw/Mcal/Adc/: Adc.c
    ./Bsw/Mcal/Iic/: Iic.c
    ./Bsw/Mcal/IrSensor/: IrSensor.c
  group Bsw_EcuAb
    ./Bsw/EcuAb/Serial/: Serial.c
    ./Bsw/EcuAb/Lcd1602/: Lcd1602.c
    ./Bsw/EcuAb/At24c02/: At24c02.c
    ./Bsw/EcuAb/Led8/: Led8.c
